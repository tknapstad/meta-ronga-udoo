# Adapted from linux-imx_${PV}.bb, copyright (C) 2013 O.S. Systems Software LTDA
# Released under the MIT license (see COPYING.MIT for the terms)

include linux-seco.inc

LOCALVERSION = "-3.0.35-seco"

COMPATIBLE_MACHINE = "(mx6)"
